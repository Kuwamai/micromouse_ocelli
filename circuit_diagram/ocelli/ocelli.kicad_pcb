# Repository Kuwamai/micromouse_ocelli

## KiCad design circuit_diagram/ocelli/ocelli.kicad_pcb

Parts:
BT1: Lipo 1cell 3.7V; pad_01x02
C1, C5, C10, C13, C25: 0.01u 5%; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 33u 50V 20%; CP_Elec_6.3x7.7
C3, C4, C11, C12, C14, C15, C16, C18, C21, C22, C23, C24, C26, C29, C30, C31: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C27: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8, C20: 4.7u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C17, C19: 2.2u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C28: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3, D5: OS5RKA5111A; LED_D5.0mm_Horizontal_O1.27mm_Z3.0mm
D4, D6, D7: OSBL1608C1A; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D8, D9: OSYL1608C1A; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
FB1: MZ1608-102Y; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3, J4: Conn_01x06; encoder_board_pad
J5: Conn_01x08; PinSocket_1x08_P1.27mm_Vertical
J6, J7: Conn_01x02; pad_01x02
LS1: PKMCS0909E4000-R1; Buzzer_Murata_PKMCS0909E
Q1, Q5, Q7, Q9, Q10: BSS138; SOT-23
Q2, Q4, Q6, Q8: ST-1KL3A
Q3: TJ8S06M3L; TO-252-2
R1, R11, R16, R25, R35: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R12, R17, R26, R36: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R14, R21, R29: 10 1/8W; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R9, R13, R18, R22, R27, R37, R38, R39, R41, R42: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R8, R15, R23, R24, R28, R30, R31, R32, R33, R34: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R20: 15; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10k 1/4W 20%; ST4ETB103
SW1: SW_SPDT; SSSS213202
SW2, SW3, SW4, SW5, SW6: TVAF06-A020B-R
U1: NJM2845DL1-33; TO-252-2
U2, U3: AS5055A; QFN-16-1EP_4x4mm_P0.65mm_EP2.7x2.7mm_PullBack
U4: ICM-20649; QFN-24-1EP_3x3mm_P0.4mm_EP1.75x1.6mm
U5: STM32F405RGTx; LQFP-64_10x10mm_P0.5mm
U6: DRV8835

Connections:
+3.3V: C2.1, C3.1, C9.1, C14.1, C16.1, C20.2, C21.2, C22.2, C23.2, C24.2, C30.2, C31.2, FB1.1, J1.1, J2.1, J5.1, LS1.1, R3.1, R5.2, R6.2, R14.1, R21.1, R22.1, R24.1, R28.1, R29.1, R31.1, R32.1, R38.1, SW6.1, U1.3 (Vout), U4.8 (VDDIO), U4.13 (VDD), U5.1 (VBAT), U5.19 (VDD), U5.32 (VDD), U5.48 (VDD), U5.64 (VDD), U6.11 (MODE), U6.12 (VCC)
+3.3VA: C25.1, C26.1, C27.1, FB1.2, Q2.1 (C), Q4.1 (C), Q6.1 (C), Q8.1 (C), U5.13 (VDDA)
+BATT: C6.1, C28.2, C29.2, Q3.2 (D), R9.1, U1.1 (Vin), U6.1 (VM)
BOOT: R33.1, SW6.2, U5.60 (BOOT0)
BUZZER: RV1.1, U5.57 (PB5)
DIR_L: U5.41 (PA8), U6.10 (AIN1/APHASE)
DIR_R: U5.43 (PA10), U6.8 (BIN1/BPHASE)
ENC_CS_L: J3.5, U2.4 (~SS)
ENC_CS_R: J4.5, U3.4 (~SS)
ENC_MISO_L: J3.3, U2.2 (MISO)
ENC_MISO_R: J4.3, U3.2 (MISO)
ENC_MOSI_L: J3.2, U2.1 (MOSI)
ENC_MOSI_R: J4.2, U3.1 (MOSI)
ENC_SCLK_L: J3.4, U2.3 (SCK)
ENC_SCLK_R: J4.4, U3.3 (SCK)
GND: BT1.2 (-), C2.2, C3.2, C4.2, C6.2, C9.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.1, C22.1, C23.1, C24.1, C25.2, C26.2, C27.2, C28.1, C29.1, C30.1, C31.1, D4.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), J1.6, J2.6, J5.3, Q1.2 (S), Q5.2 (S), Q7.2 (S), Q9.2 (S), Q10.2 (S), R2.2, R4.2, R8.2, R10.2, R12.2, R13.2, R15.2, R17.2, R18.2, R23.2, R26.2, R27.2, R30.2, R33.2, R34.2, R36.2, RV1.3, SW1.1 (A), SW2.2, SW3.2, SW4.2, SW5.2, U1.2 (GND), U4.11 (FSYNC), U4.18 (GND), U4.20 (RESV), U5.12 (VSSA), U5.18 (VSS), U5.63 (VSS), U6.6 (GND)
GND_L: C7.1, C11.2, J3.6, U2.9 (TEST), U2.13 (VSS)
GND_R: C8.1, C12.2, J4.6, U3.9 (TEST), U3.13 (VSS)
LED0: R37.1, U5.40 (PC9)
LED1: R39.1, U5.39 (PC8)
LED2: R41.1, U5.38 (PC7)
LED3: R42.1, U5.37 (PC6)
LEFT_FRONT_AD: C13.2, R30.1, U5.27 (PB1)
LEFT_FRONT_IR: R25.2, U5.30 (PB11)
LEFT_MOTOR+: J7.1, U6.2 (AOUT1)
LEFT_MOTOR-: J7.2, U6.3 (AOUT2)
LEFT_SIDE_AD: C5.2, R15.1, U5.26 (PB0)
LEFT_SIDE_IR: R11.1, U5.33 (PB12)
NRST: C18.1, J5.5, SW5.1, U5.7 (NRST)
unnamed: BT1.1 (+), Q3.3 (S), R7.2
unnamed: C1.1, Q2.2 (E), R4.1
unnamed: C5.1, Q4.2 (E), R13.1
unnamed: C7.2, R19.1, U2.12 (VDD)
unnamed: C8.2, R20.1, U3.12 (VDD)
unnamed: C10.1, Q6.2 (E), R18.1
unnamed: C13.1, Q8.2 (E), R27.1
unnamed: C15.1, U4.10 (REGOUT)
unnamed: C17.1, U5.31 (VCAP_1)
unnamed: C19.1, U5.47 (VCAP_2)
unnamed: D1.1 (K), Q1.3 (D)
unnamed: D1.2 (A), R3.2
unnamed: D2.1 (K), Q5.3 (D)
unnamed: D2.2 (A), R14.2
unnamed: D3.1 (K), Q7.3 (D)
unnamed: D3.2 (A), R21.2
unnamed: D4.2 (A), R22.2
unnamed: D5.1 (K), Q9.3 (D)
unnamed: D5.2 (A), R29.2
unnamed: D6.2 (A), R37.2
unnamed: D7.2 (A), R39.2
unnamed: D8.2 (A), R41.2
unnamed: D9.2 (A), R42.2
unnamed: LS1.2, Q10.3 (D), R38.2
unnamed: Q1.1 (G), R1.2, R2.1
unnamed: Q3.1 (G), R7.1, SW1.2 (B)
unnamed: Q5.1 (G), R11.2, R12.1
unnamed: Q7.1 (G), R16.1, R17.1
unnamed: Q9.1 (G), R25.1, R26.1
unnamed: Q10.1 (G), R35.1, R36.1
unnamed: R34.1, U5.28 (PB2)
unnamed: R35.2, RV1.2
PWM_L: U5.42 (PA9), U6.9 (AIN2/AENBL)
PWM_R: U5.44 (PA11), U6.7 (BIN2/BENBL)
RIGHT_FRONT_AD: C10.2, R23.1, U5.24 (PC4)
RIGHT_FRONT_IR: R16.2, U5.15 (PA1)
RIGHT_MOTOR+: J6.1, U6.4 (BOUT1)
RIGHT_MOTOR-: J6.2, U6.5 (BOUT2)
RIGHT_SIDE_AD: C1.2, R8.1, U5.25 (PC5)
RIGHT_SIDE_IR: R1.1, U5.14 (PA0)
SPI1_CS: R28.2, U4.22 (nCS), U5.54 (PD2)
SPI1_MISO: U4.9 (SDO/AD0), U5.52 (PC11)
SPI1_MOSI: U4.24 (SDA/SDI), U5.53 (PC12)
SPI1_SCLK: U4.23 (SCL/SCLK), U5.51 (PC10)
SPI2_CS0: J1.5, R5.1, U5.9 (PC1)
SPI2_CS1: J2.5, R6.1, U5.2 (PC13)
SPI2_MISO: J1.3, J2.3, U5.10 (PC2)
SPI2_MOSI: J1.2, J2.2, U5.11 (PC3)
SPI2_SCLK: J1.4, J2.4, U5.29 (PB10)
SWCLK: J5.2, U5.49 (PA14)
SWDIO: J5.4, U5.46 (PA13)
SWO: J5.6, U5.55 (PB3)
SW_0: R24.2, SW2.1, U5.36 (PB15)
SW_1: R31.2, SW3.1, U5.35 (PB14)
SW_2: R32.2, SW4.1, U5.34 (PB13)
UART_RX: J5.7, U5.17 (PA3)
UART_TX: J5.8, U5.16 (PA2)
VBAT_AD: C4.1, R9.2, R10.1, U5.8 (PC0)
VDD_L: C11.1, J3.1, R19.2, U2.11 (VDDp), U2.14 (WM)
VDD_R: C12.1, J4.1, R20.2, U3.11 (VDDp), U3.14 (WM)

Notes on the sheet:
Buzzer
表記のない抵抗の定格電力、許容誤差は1/10W、±1% 表記のないコンデンサの耐圧、許容誤差は10V、±10%
Switch
Micon
LED
Motor Driver
IMU
Encoder
Power
Sensor

Board: 2 copper layers, 89.8 x 58.8 mm, 115 parts (8 on the bottom side), 89 nets.

Other parts of the board:
R: MountingHole_2.2mm_M2

## Code that names these connections

File mouse_program/mouse_program.ioc (part):

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Mcu.Name=STM32F405RGTx
Mcu.Package=LQFP64
Mcu.UserName=STM32F405RGTx
PA0-WKUP.GPIOParameters=GPIO_Label
PA0-WKUP.GPIO_Label=RIGHT_SIDE_IR
PA0-WKUP.Signal=GPIO_Output
PA1.GPIOParameters=GPIO_Label
PA1.GPIO_Label=RIGHT_FRONT_IR
PA1.Signal=GPIO_Output
PA10.Signal=GPIO_Output
PA11.Signal=S_TIM1_CH4
PA13.Mode=Trace_Asynchronous_SW
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Trace_Asynchronous_SW
PA14.Signal=SYS_JTCK-SWCLK
PA2.Mode=Asynchronous
PA2.Signal=USART2_TX
PA3.Mode=Asynchronous
PA3.Signal=USART2_RX
PA8.Signal=GPIO_Output
PA9.Signal=S_TIM1_CH2
PB0.Signal=ADCx_IN8
PB1.Signal=ADCx_IN9
PB10.Mode=Full_Duplex_Master
PB10.Signal=SPI2_SCK
PB11.GPIOParameters=GPIO_Label
PB11.GPIO_Label=LEFT_FRONT_IR
PB11.Signal=GPIO_Output
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=LEFT_SIDE_IR
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Label
PB13.GPIO_Label=SW2
PB13.Signal=GPIO_Input
PB14.GPIOParameters=GPIO_Label
PB14.GPIO_Label=SW1
PB14.Signal=GPIO_Input
PB15.GPIOParameters=GPIO_Label
PB15.GPIO_Label=SW0
PB15.Signal=GPIO_Input
PB3.Mode=Trace_Asynchronous_SW
PB3.Signal=SYS_JTDO-SWO
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=BUZZER
PB5.Signal=S_TIM3_CH2
PC0.Signal=ADCx_IN10
PC1.GPIOParameters=GPIO_Label
PC1.GPIO_Label=SPI2_CS0
PC1.Signal=GPIO_Output
PC10.Mode=Full_Duplex_Master
PC10.Signal=SPI3_SCK
PC11.Mode=Full_Duplex_Master
PC11.Signal=SPI3_MISO
PC12.Mode=Full_Duplex_Master
PC12.Signal=SPI3_MOSI
PC13-ANTI_TAMP.GPIOParameters=GPIO_Label
PC13-ANTI_TAMP.GPIO_Label=SPI2_CS1
PC13-ANTI_TAMP.Signal=GPIO_Output
PC2.Mode=Full_Duplex_Master
PC2.Signal=SPI2_MISO
PC3.Mode=Full_Duplex_Master
PC3.Signal=SPI2_MOSI
PC4.Signal=ADCx_IN14
PC5.Signal=ADCx_IN15
PC6.Signal=GPIO_Output
PC7.Signal=GPIO_Output
PC8.Signal=GPIO_Output
PC9.Signal=GPIO_Output
PD2.Signal=GPIO_Output
RCC.HSE_VALUE=25000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2021-10-29 Added block_diagram
2021-10-29 Update block_diagram
2022-07-06 ブロック図のフォーマット変更
2022-07-06 ブロック図を回路関係フォルダに移動
2022-07-06 ブロック図に型番記入
2022-07-20 KiCAD用gitignore追加
2022-07-21 KiCADプロジェクト作成
2022-07-21 フォトリフレクタ追加
2022-07-26 モータドライバ追加
2022-07-28 LED追加
2022-08-03 IMUとか追加
2022-08-04 レイアウト調整
2022-08-16 edit
2022-08-16 書き込みコネクタ追加
2022-08-23 回路図PDF追加
2022-08-23 スタイル調整
2022-08-23 ラベル名変更
2022-08-24 ブザー修正
2022-08-24 文字位置修正
2022-08-24 バッテリー電圧の表記追加
2022-08-24 モータドライバプルアップ抵抗の削除
2022-08-24 マイコン電源のパスコン追加
2022-08-26 アノテーション実行
2022-08-29 コンデンサの選定
2022-08-30 抵抗の選定
2022-08-31 距離センサ用抵抗の定格電力修正
2022-09-01 CubeMXの出力追加
2022-09-03 フットプリント追加
2022-09-05 使用するコンデンサを変更
2022-09-09 フットプリント割当完了
2022-09-14 基板外形追加、部品配置途中
2022-09-16 モータマウント等のスケッチ追加
2022-09-16 エンコーダ基板投影図追加
2022-09-16 モータ位置変更
2022-09-26 部品配置中
2022-10-17 一通りパターンを繋いだ
2022-10-21 対処すべきDRCエラーに対処した
2022-10-24 適当にビアを打ってみた
2022-10-26 アイコンシルク追加
2022-10-31 フットプリント修正
2022-11-08 バッテリコネクタ変更
2022-11-16 部品リスト追加
2022-11-16 Gerberデータ追加
2022-11-16 gerber設定追加
2022-12-28 Lチカコード
2022-12-28 古いプロジェクトを削除
2022-12-28 Lチカコード追加
2023-01-12 PWM出力によるモータの正転逆転の確認
2023-01-13 ピンアサイン修正
2023-01-16 WHO_AM_Iできた
2023-01-18 gitignore更新
2023-01-18 Z軸角速度が取得できた
2023-01-18 不要なファイルを削除
2023-01-24 角度が読めない
2023-01-26 for文の追加
2023-01-30 エンコーダの値を確認
2023-02-08 delay_us追加、壁センサの動作確認完了
2023-02-13 TIM4の割り込み設定
2023-02-14 割り込み関数で壁センサの取得
2023-02-14 割り込み関数生成
2023-02-15 変数名変更
2023-02-15 エンコーダ値を取得
2023-02-15 エンコーダ値の変化量を取得
2023-02-15 エンコーダ値を速度に変換
2023-02-15 duty比の計算
2023-02-15 PWM出力
2023-02-16 速度制御実装
2023-02-16 速度制御実装 (#28)
    * 割り込み関数生成
    * 変数名変更
    * エンコーダ値を取得
    * エンコーダ値の変化量を取得
    * エンコーダ値を速度に変換
    * duty比の計算
2023-02-16 移動距離の計測
2023-02-17 モード選択とLED制御実装
2023-02-17 台形速度制御関数追加
2023-02-17 台形速度制御 (#29)
    * 移動距離の計測
    * モード選択とLED制御実装
    * 台形速度制御関数追加
2023-02-17 角度計測
2023-02-17 imu初期化関数
2023-02-17 電圧監視
2023-02-17 コメント追加
2023-02-18 角速度制御
2023-02-18 角速度制御のゲインをいい感じにした
2023-02-18 旋回関数
2023-02-18 台形角速度制御実装 (#30)
    * 角度計測
    * imu初期化関数
    * 電圧監視
    * コメント追加
    * 角速度制御
    * 角速度制御のゲインをいい感じにした
2023-02-18 バッテリーが切れそうになったらLEDを点滅
2023-02-18 センサ値を構造体で管理
2023-02-18 コミット忘れ
2023-02-18 壁の有無判定
2023-02-18 不要な変数を削除
2023-02-18 壁制御偏差算出
2023-02-18 壁制御実装
2023-02-18 壁がないときは制御しない
2023-02-18 壁制御 (#32)
    * センサ値を構造体で管理
    * コミット忘れ
    * 壁の有無判定
    * 不要な変数を削除
    * 壁制御偏差算出
    * 壁制御実装
2023-02-18 HM-Kit足立法移植中
2023-02-18 マップの初期化を忘れていた。走るようになってきた
2023-02-18 ゲイン調整
2023-02-18 前壁が近いときは壁制御しない
2023-02-18 タイヤ直径とか調節した
2023-02-18 移動平均フィルター使ったらセンサノイズ減った。迷路サイズ小さくしたら処理が軽くなった?
2023-02-20 全日本大会用調整
2023-02-21 足立法 (#33)
    * HM-Kit足立法移植中
    * マップの初期化を忘れていた。走るようになってきた
    * ゲイン調整
    * 前壁が近いときは壁制御しない
    * タイヤ直径とか調節した
    * 移動平均フィルター使ったらセンサノイズ減った。迷路サイズ小さくしたら処理が軽くなった?
2023-04-19 パラメータ調整
2023-04-24 不要な走行距離計算を削除
2023-04-24 移動距離のリセットタイミングを修正
2023-04-24 走行中にモータをOFFにする不具合修正
2023-04-26 実験用迷路ゴール位置設定
2023-04-26 計測距離のリセットタイミング修正 (#39)
    * パラメータ調整
    * 不要な走行距離計算を削除
    * 移動距離のリセットタイミングを修正
    * 走行中にモータをOFFにする不具合修正
    * 実験用迷路ゴール位置設定
2023-04-26 doubleの数値をfloatに変更
2023-04-28 社内大会用パラメータ
2023-12-20 kicad 7対応
2023-12-20 探索用コード作成
